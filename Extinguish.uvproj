# Keil uVision project Extinguish.uvproj, settings and files
target Extinguish (ARM-ADS)
  device: LPC1777 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Extinguish
  AfterMake: fromelf --bin --output .\compile_out\Extinguish.bin ..\compile_middle\Extinguish.axf
  c flags: Optim=1
  c include: .\s00_main;.\s01_Inc;.\s02_incAssemble;.\s03_Task;.\s05_Common;.\s08_Board;.\s09_Struct;.\s20_LcdManage;.\s22_LcdPage;.\s23_LcdSub;.\s28_LcdConst;.\s29_LcdOpeaMenuLib;.\s40_canPrtlStr;.\s41_Can11S;.\s41_CanProtocal;.\s42_CanManage;.\s44_CanBufLib;.\s47_EventBuf;.\s70_Periph;.\s71_PhInterface;.\s76_phSaveTask;.\s77_phSaveDef;.\s78_phSaveLib;.\s80_HardWareCpu;.\s81_HardWareEx;.\s82_HardWareLcdLib;.\s85_cpuDef;.\s86_driver;.\s83_CharLib;.\s48_EventBufCode;.\s49_EventBufWin;.\s50_EventBufDef;.\s07_State;.\s78_10_FlsInterface;.\s78_20_SaveCacu;.\s78_22_Manage;.\s78_23_Queue;.\s78_24_Hist;.\s78_26_SaveBuf;.\s78_30_SaveSim;.\s78_40_ItemM;.\s78_41_ItemOnePage;.\s78_42_ItemQueue;.\s78_43_ItemSerialFixAdr;.\s78_44_ItemSerialUnFixAdr;.\s78_01_incAssemble
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group assist
    ./s90_Assist/: xxx.c xxx.h Version.h regular.h ProjectDescription.h ProjectStruct.h testCode.h bakCode.h
  group startUp
    ./s00_startUp/: startup.s
  group main
    ./s00_main/: main.c mRunTask.c mRunTask.h mTask_Test.c mTask_Test.h
  group s01_inc
    ./s01_Inc/: prjCompileCon.h prjDataType.h prjFosc.h prjBool.h sysDef.c sysDef.h incCommonPeriph.h incCommonHwEx.h incCommonHwCpu.h hwAndLib.h incFile.h
  group s02_incAssemble
    ./s02_incAssemble/: incSysCommon.h
  group s05_Common
    ./s05_Common/: bufCircle.c bufCircle.h codeComm.c codeComm.h codeCrc.c codeCrc.h codeFig.c codeFig.h cstBits.c cstBits.h
  group s07_State
    ./s07_State/: tmrTick.c tmrTick.h sysStatus.c sysStatus.h OpeaAndEvtState.c OpeaAndEvtState.h
  group s08_Board
    ./s08_Board/: meBoard.c meBoard.h sysMachine.c sysMachine.h sysPanel.c sysPanel.h
  group s09_Struct
    ./s09_Struct/: canFrame.c canFrame.h loopFieldTypeState.h strClock.h strDevice.c strDevice.h strDevMLAT.h strEvtTrans.c strEvtTrans.h
  group s20_LcdManage
    ./s20_LcdManage/: tsk_lcd_incIn.h lcd_Para.h lcdShowTask.c lcdShowTask.h lcdPg_aSchedu.c lcdPg_aSchedu.h lcdPg_MainOrEvt.c lcdPg_MainOrEvt.h lcdPg_Status.c lcdPg_Status.h lcdTsk_PgNum.c lcdTsk_PgNum.h lcdPg_MainAndEvtChange.c lcdPg_MainAndEvtChange.h
  group s22_LcdPage
    ./s22_LcdPage/: lcdPg_Page.c lcdPg_Page.h lcdPg_Common.c lcdPg_Common.h lcdPg_pSelfChk.c lcdPg_pSelfChk.h lcdPg_pSelfHdChk.c lcdPg_pSelfHdChk.h lcdPg_pUserLogin.c lcdPg_pUserLogin.h lcdPg_ShowEvt.c lcdPg_ShowEvt.h lcdPg_InitT.c lcdPg_InitT.h lcdPg_KeyCall.c lcdPg_KeyCall.h posText.c posText.h lcdPg_ShowLineFun.c lcdPg_ShowLineFun.h
  group s23_LcdSub
    ./s23_LcdSub/: lcdSub_Flash.c lcdSub_Flash.h lcdSub_InputFig.c lcdSub_InputFig.h lcdSub_ModeTextFig.c lcdSub_ModeTextFig.h lcdSub_Pssw.c lcdSub_Pssw.h lcdSub_SwDev.c lcdSub_SwDev.h lcdSub_SwOneEvt.c lcdSub_SwOneEvt.h lcdSub_SwOneMiniEvt.h lcdSub_SwOneMiniEvt.c
  group s28_LcdConst
    ./s28_LcdConst/: lcdCst_Menu.c lcdCst_Menu.h lcdCst_Page.c lcdCst_Page.h lcdCst_PageFunction.h lcdCst_PageNum.h lcdCst_PgStrDeteType.c lcdCst_PgStrDeteType.h lcdCst_PgStrEvtThing.c lcdCst_PgStrEvtThing.h lcdCst_PgString.c lcdCst_PgString.h lcdCst_WhenModify.h
  group s29_LcdOpeaMenuLib
    ./s29_LcdOpeaMenuLib/: lcdCst_OpaMenu_Inc_extern.h lcdCst_OpaMenuInterface.c lcdCst_OpaMenuInterface.h lcdCst_OpeaMenu.c lcdCst_OpeaMenu.h OpeaMenu_Driver_V0.0.0.1_0.0.8.lib opeaMenuLib_incOut.h
  group s40_canPrtlStr
    ./s40_canPrtlStr/: can_DataOrFile.c can_DataOrFile.h canProtocalStr.c canProtocalStr.h
  group s41_Can11S
    ./s41_Can11S/: can11sFile.c can11sFile.h can11sPrtl_eCan.c can11sPrtl_eCan.h can11sPrtl_eRx.c can11sPrtl_eRx.h can11sPrtl_eTx.c can11sPrtl_eTx.h can11sPrtl_iCan.c can11sPrtl_iCan.h can11sPrtl_iRx.c can11sPrtl_iRx.h can11sPrtl_iTx.c can11sPrtl_iTx.h can11sPrtlComm.c can11sPrtlComm.h CCan_11S_Def.h
  group s41_CanProtocal
    ./s41_CanProtocal/: canPrtl_eCan.c canPrtl_eCan.h canPrtl_eRx.c canPrtl_eRx.h canPrtl_eTx.c canPrtl_eTx.h canPrtl_File.c canPrtl_File.h canPrtl_iCan.c canPrtl_iCan.h canPrtl_iRx.c canPrtl_iRx.h canPrtl_iTx.c canPrtl_iTx.h canPrtlComm.c canPrtlComm.h
  group s42_CanManage
    ./s42_CanManage/: Can_Manage.c Can_Manage.h CanTxTask.c CanTxTask.h eCanRxTask.c eCanRxTask.h iCanRxTask.c iCanRxTask.h CanHd_Interface.c CanHd_Interface.h CanIntCouple.c CanIntCouple.h CanIntRxBuf.c CanIntRxBuf.h
  group s44_CanBufLib
    ./s44_CanBufLib/: CanBufLib_incOut.h CanBufLib_RxFile_incOut.h CanBufLib_TxFile_incOut.h CanBufLib_TxRx_Buf.h CanBufLib_TxState.h CanBufLib_strFileProp.h CanBufLib_ReDef.h canBufLib_Inc_Extern.h CanBuf_Driver_V0.0.0.1_0.0.8.lib
  group s47_EventBuf
    ./s47_EventBuf/: evtThingDef.h evt_Buf_incOut.h evt_Buf_incIn_Extern.h evt_Para.h evt_Class.c evt_Class.h evtStrCommon.h evtStrDef.h EventBuf_Driver_V0.0.0.1_1.7.lib
  group s70_Periph
    ./s70_Periph/: phClock.c phClock.h phWatchDogTask.h phWatchDogTask.c phIoLed.c phIoLed.h phIoScan.c phIoScan.h phIoSound.c phIoSound.h phIoKeyScan.c phIoKeyScan.h keyBufJdgLib_Inc_Extern.h keyBufJdgLib_incOut.h KeyBuf_Driver_V0.0.0.1_0.0.5.lib phIoPwrChkSwitch.c phIoPwrChkSwitch.h phIoPwrState.c phIoPwrState.h
  group s71_PhInterface
    ./s71_PhInterface/: CpuReg.c CpuReg.h HdInterface.c HdInterface.h hw00_CallBack.c hw00_CallBack.h hw00_HdInt.c hw00_HdInt.h UartHd_Interface.c UartHd_Interface.h fls_Interface.c fls_Interface.h
  group s76_phSaveTask
    ./s76_phSaveTask/: saveTask.c saveTask.h saveTmrPwroffAndHist.c saveTmrPwroffAndHist.h saveItemAux.c saveItemAux.h
  group s77_phSaveDef
    ./s77_phSaveDef/: flsStoreBytesDef.h flsReDef.h historyClsDef.h strFlsAdrDef.c strFlsAdrDef.h strFlsItmStruct.h strFlsQue.h
  group s78_phSaveLib
    ./s78_phSaveLib/: Save_Hist_incOut.h Save_Item_incOut.h Save_Manage_incOut.h saveInc_Extern.h
  group s78_30_SaveSim
    ./s78_30_SaveSim/: sim_saveItem.c sim_saveItem.h
  group s78_01_incAssemble
    ./s78_01_incAssemble/: saveInc_Common.h SaveTask_incIn.h
  group s78_10_FlsInterface
    ./s78_10_FlsInterface/: flsErase.c flsErase.h flsWrite.c flsWrite.h
  group s78_20_SaveCacu
    ./s78_20_SaveCacu/: flsAdrCalculate.c flsAdrCalculate.h strFlsItmStrCacu.c strFlsItmStrCacu.h
  group s78_22_Manage
    ./s78_22_Manage/: flashIdAssign.c flashIdAssign.h flsCopyTask.c flsCopyTask.h flsItemState.c flsItemState.h saveManage.c saveManage.h
  group s78_23_Queue
    ./s78_23_Queue/: flsInqPoint.c flsInqPoint.h strFlsQue.c
  group s78_24_Hist
    ./s78_24_Hist/: historyRead.c historyRead.h historyWrBuf.c historyWrBuf.h historyWrite.c historyWrite.h phSaveHist_incIn.h saveHistory.c saveHistory.h saveHistPoint.c saveHistPoint.h
  group s78_26_SaveBuf
    ./s78_26_SaveBuf/: flsWrApplyBuf.c flsWrApplyBuf.h flsWrApplySave.c flsWrApplySave.h
  group s78_40_ItemM
    ./s78_40_ItemM/: saveItem_incIn.h saveOthers.c saveOthers.h
  group s78_41_ItemOnePage
    ./s78_41_ItemOnePage/: saveExtgZoneConfig.c saveExtgZoneConfig.h saveMachProbat.c saveMachProbat.h saveMeStatus.c saveMeStatus.h saveNetMachine.c saveNetMachine.h savePnConfig.c savePnConfig.h saveUserLogin.c saveUserLogin.h
  group s78_42_ItemQueue
    ./s78_42_ItemQueue/: savePowerOff.c savePowerOff.h
  group s78_43_ItemSerialFixAdr
    ./s78_43_ItemSerialFixAdr/: saveField.c saveField.h saveLinkProg.c saveLinkProg.h saveNote.c saveNote.h
  group s78_44_ItemSerialUnFixAdr
    ./s78_44_ItemSerialUnFixAdr/: saveDisable.c saveDisable.h saveRelateAddr.c saveRelateAddr.h
  group s80_HardWareCpu
    ./s80_HardWareCpu/: CUart.c CUart.h hd03_Gpio.c hd03_Gpio.h hd04_PinFunc.c hd04_PinFunc.h hw01_Timer.c hw01_Timer.h hw16_IIC.c hw16_IIC.h hw10_Can.c hw10_Can.h hw10_MaskCan.c hw10_MaskCan.h hw20_AD.c hw20_AD.h
  group s81_HardWareEx
    ./s81_HardWareEx/: hwEx10_PinDef.c hwEx10_PinDef.h hwEx10_GpioDef.c hwEx10_GpioDef.h hwEx03_Pcf8563.c hwEx03_Pcf8563.h hwEx21_SST39vf800A.c hwEx21_SST39vf800A.h nandflash_hy27uf081g2a.h nandflash_hy27uf081g2a.c
  group s82_HardWareLcdLib
    ./s82_HardWareLcdLib/: hwEx11_lcd_Def_charLib.h hwEx11_lcd_DefPara.h hwEx13_lcd_DataType.h Lcd_swBuf_Task.h Lcd_swBuf_Text.h Lcd_swBuf_Figure.h Lcd_swBuf_Graph.h Lcd_swBuf_Ascii.h Lcd_swBuf_Fig88.h LcdLib_Inc_Extern.c LcdLib_Inc_Extern.h LcdLib_incOut.h Lcd_Driver_V0.0.0.1_10_Cn12En6Asc6.lib
  group s83_CharLib
    ./s83_CharLib/: hwEx16_charLib12.c hwEx16_charLib16.c hwEx16_charLibAscii08.c hwEx16_charLibAscii08.h hwEx16_charLibAscii126.c hwEx16_charLibAscii128.c charLib_Inc_Extern.h
  group s85_cpuDef
    ./s85_cpuDef/: core_cm3.h LPC177x_8x.h
  group s86_driver
    ./s86_driver/: lpc177x_8x_adc.h lpc177x_8x_can.h lpc177x_8x_clkpwr.h lpc177x_8x_crc.h lpc177x_8x_emac.h lpc177x_8x_emc.h lpc177x_8x_gpio.h lpc177x_8x_i2c.h lpc177x_8x_libcfg_default.h lpc177x_8x_nvic.h lpc177x_8x_pinsel.h lpc177x_8x_pwm.h lpc177x_8x_qei.h lpc177x_8x_systick.h lpc177x_8x_timer.h lpc177x_8x_uart.h lpc177x_8x_wwdt.h Lpc177xDriverLib_V1.0_2.lib system_LPC177x_8x.h lpc_types.h
